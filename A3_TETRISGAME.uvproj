# Keil uVision project A3_TETRISGAME.uvproj, settings and files
target A3_TETRISGAME (6220000::V6.22::ARMCLANG)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: Tutorial_8_LCD_emWin
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Library\Device\Nuvoton\M480\Include;.\Library\StdDriver\inc;.\Library\emWin\Config;.\Library\emWin\Include;.\Library\tslib;.\Library\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
--diag_suppress=L6329
  group Libraries
    ./Library/Device/Nuvoton/M480/Source/: system_M480.c
    ./Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
    ./Library/StdDriver/src/: clk.c eadc.c ebi.c gpio.c fmc.c retarget.c sys.c timer.c uart.c
  group emWin
    ./Library/emWin/Config/: GUI_X.c LCDConf.c
    ./Library/emWin/Lib/: NUemWin_CM4_Keil.lib
  group Application
    ./Application/Resource/Image/: pixel.c
    ./Application/Resource/Font/: NettoOT_32_Normal_EXT_AA4.c NettoOT_40_Normal_EXT_AA4.c
    ./Application/Resource/Text/: APPW_Language_0.c
    ./Application/Source/: APPW_MainTask.c
    ./Application/Source/Generated/: APPWConf.c ID_GAME_OVER.c ID_SCREEN_HIGH_SCORE.c ID_SCREEN_PLAY.c ID_SCREEN_WELCOME.c Resource.c
    ./Application/Source/CustomCode/: Application.c ID_GAME_OVER_Slots.c ID_SCREEN_HIGH_SCORE_Slots.c ID_SCREEN_PLAY_Slots.c ID_SCREEN_WELCOME_Slots.c
  group tslib
    ./Library/tslib/: M48XTouchPanel.c ts_calibrate.c
  group src
    ./: main.c
    ./Library/: GUIConf.c
target emWin_SimpleDemo_SD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: as above
  output: emWin_SimpleDemo_SD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __USE_SD__
  c include: ..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\tslib;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\Library\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: as above
